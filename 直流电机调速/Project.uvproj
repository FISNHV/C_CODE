# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../10-2 DS1302可调时钟/: Delay.c Delay.h Key.c Key.h Timer0.c Timer0.h
    ../11-1 蜂鸣器播放提示音/: Nixie.c Nixie.h
